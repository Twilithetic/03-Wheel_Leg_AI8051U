# Keil uVision project 03-March_Wheel_leg_FOC.uvproj, settings and files
target 03-March_Wheel_leg_FOC (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: 03-March_Wheel_leg_FOC +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group User Sources
    ./Sources/: drv8311.c
  group AiCube
    ./Sources/: main.c pwm.c adc.c port.c
    ./Sources/lib/: ai8051u_32_mdu32.lib ai8051u_32_tfpu.lib stc_usb_cdc_32g_xdata.lib
